# Keil uVision project CLV_IOT_Demo.uvprojx, settings and files
target CLV_IOT_Demo (ARM-ADS)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CLV_IOT_Demo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\Library\CMSIS;..\Library\Library\inc;..\User;..\User\LED_Driver;..\User\RCC_Driver;..\User\BEEP_Driver;..\User\SysTick_Driver.c;..\User\KEY_Driver;..\User\USART_Driver;..\User\TIM_Driver
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_conf.h stm32f4xx_it.c stm32f4xx_it.h
    ../User/LED_Driver/: Led_Driver.c
    ../User/RCC_Driver/: Rcc_Driver.c
    ../User/BEEP_Driver/: Beep_Driver.c
    ../User/SysTick_Driver.c/: SysTick_Driver.c
    ../User/KEY_Driver/: Key_Driver.c
    ../User/USART_Driver/: Usart_Driver.c
    ../User/TIM_Driver/: Tim_Driver.c
  group Doc
    ../Doc/: Readme.txt
  group Libraries
    ../Library/Library/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_spi.c stm32f4xx_sdio.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group CMSIS
    ../Library/CMSIS/: system_stm32f4xx.c
  group StartUp
    ../Library/CMSIS/: startup_stm32f40_41xxx.s
